PROVIDES = "virtual/elfrealloc"
